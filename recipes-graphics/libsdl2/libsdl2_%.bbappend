PACKAGECONFIG:append = " kmsdrm"